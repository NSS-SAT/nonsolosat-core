KV = "4.4.35"
SRCDATE = "20230214"

require uclan-dvb-modules-hisi.inc

SRC_URI[md5sum] = "b51b0b61b682149b9e2ec0d3d4f88807"
SRC_URI[sha256sum] = "9b0c1f635ad9f4207cd9f3944c93f1408bc613288d72e76da506b52d896e560a"
