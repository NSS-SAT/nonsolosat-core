KV = "4.4.176"
SRCDATE = "20230217"

require uclan-dvb-modules-hisi.inc

SRC_URI[md5sum] = "9cc69a5345133fbf7f8f8ff17b8d4623"
SRC_URI[sha256sum] = "5fa0dc86145577cbde022340239d3f67c497f8296cdc2cc343eb8c3672094618"
